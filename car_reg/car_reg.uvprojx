# Keil uVision project car_reg.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: car_reg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\Start;.\User;.\Dri;.\Int;.\Mid;.\App;.\Com;.\Mid\FreeRTOS;.\Mid\FreeRTOS\include;.\Mid\FreeRTOS\Portable;.\Mid\FreeRTOS\Source;.\Int\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c main.h
  group Dri
    ./Dri/: Dri_TIM.c Dri_TIM.h Dri_USART1.c Dri_USART1.h Dri_I2C.c Dri_I2C.h Dri_ADC.c Dri_ADC.h Dri_SPI.c Dri_SPI.h Dri_USART2.c Dri_USART2.h
  group Int
    ./Int/: Int_TB6612.h Int_TB6612.c Int_Encoder.c Int_Encoder.h Int_MPU6050.h Int_MPU6050.c
    ./Int/OLED/: oled.c
  group App
    ./App/: App_Car.c App_Car.h App_Task.c App_Task.h
  group Com
    ./Com/: Com_Filter.c Com_Filter.h Com_PID.c Com_PID.h
  group Mid/FreeRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FrreeRTOS/Source
    ./Mid/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/Portable
    ./Mid/FreeRTOS/Portable/: heap_4.c port.c
